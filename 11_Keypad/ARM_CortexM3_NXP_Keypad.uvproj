# Keil uVision project ARM_CortexM3_NXP_Keypad.uvproj, settings and files
target ARM_CortexM3_NXP (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ARM_CortexM3_NXP_Keypad +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Keil_v5\ARM\INC\NXP\LPC17xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s
  group System Code
    ./: system_LPC17xx.c
  group Core Code
    ./: core_cm3.c
  group Source Code
    ./: ARM_CortexM3_Keypad.c
