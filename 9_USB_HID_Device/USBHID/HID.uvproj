# Keil uVision project HID.uvproj, settings and files
target MCB1700 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: HID +hex
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Keil_v5\ARM\INC\NXP\LPC17xx
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Files
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Source Files
    ./: usbdesc.c hiduser.c usbhw_LPC17xx.c usbcore.c demo.c usbuser.c usbcfg_LPC17xx.h
  group Documentation
    ./: Abstract.txt
