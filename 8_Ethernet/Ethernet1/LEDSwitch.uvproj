# Keil uVision project LEDSwitch.uvproj, settings and files
target MCB1700 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LEDSwitch +hex
  c flags: wLevel=2
  c include: C:\Keil_v5\ARM\INC\NXP\LPC17xx;..\..\..\lpc175x_6x_cmsis_driver_library\Drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20080000 size 0x8000
  group Configuration Files
    C:/Keil_v5/ARM/RL/TCPnet/Config/: Net_Config.c
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Library
    C:/Keil_v5/ARM/RV31/LIB/: TCP_CM3.lib TCPD_CM3.lib
    C:/Keil_v5/ARM/RL/TCPnet/Drivers/: EMAC_LPC17xx.c
  group Source Files
    ./: LED.c LEDSwitch.c
