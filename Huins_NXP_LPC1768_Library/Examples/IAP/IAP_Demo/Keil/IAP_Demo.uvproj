# Keil uVision project IAP_Demo.uvproj, settings and files
target LPC1700 FLASH (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: iap_test +hex
  c flags: Optim=1 wLevel=2
  c define: __RAM_MODE__=0, __BUILD_WITH_EXAMPLE__
  c include: ..\..\..\..\Drivers\include;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC17xx\Include;..\..\IAP_Demo
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ../../../../Core/Device/NXP/LPC17xx/Source/Templates/ARM/: startup_LPC17xx.s
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC17xx/Source/Templates/: system_LPC17xx.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc17xx_clkpwr.c lpc17xx_pinsel.c lpc17xx_uart.c lpc17xx_iap.c
  group Main
    ../: iaptest.c
  group Readme
    ../: abstract.txt
target LPC1700 RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: iap_test +hex
  c flags: Optim=1 wLevel=2
  c define: __RAM_MODE__=1, __BUILD_WITH_EXAMPLE__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
