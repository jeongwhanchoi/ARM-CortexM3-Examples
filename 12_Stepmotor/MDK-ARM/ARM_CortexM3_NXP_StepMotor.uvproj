# Keil uVision project ARM_CortexM3_NXP_StepMotor.uvproj, settings and files
target ARM_CortexM3_NXP (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ARM_CortexM3_NXP_StepMotor +hex
  c flags: Optim=1 wLevel=2
  c include: ..\..\Huins_NXP_LPC1768_Library\Core\Device\NXP\LPC17xx\Include;..\..\Huins_NXP_LPC1768_Library\Drivers\include;..\Inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Driver
    ../../Huins_NXP_LPC1768_Library/Drivers/source/: debug_frmwrk.c lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_libcfg_default.c lpc17xx_pinsel.c lpc17xx_uart.c LPC1768_motor.c LPC1768_utility.c
  group Source Code
    ../Src/: StepMotor.c
  group Readme
    ../: Example Manual.txt
