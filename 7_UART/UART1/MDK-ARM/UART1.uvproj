# Keil uVision project UART1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: UART1 +hex
  c flags: wLevel=2
  c include: ..\..\..\Huins_NXP_LPC1768_Library\Core\Device\NXP\LPC17xx\Include;..\..\..\Huins_NXP_LPC1768_Library\Drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Drivers
    ../../../Huins_NXP_LPC1768_Library/Drivers/source/: lpc17xx_clkpwr.c lpc17xx_pinsel.c lpc17xx_uart.c lpc17xx_libcfg_default.c debug_frmwrk.c LPC1768_utility.c lpc17xx_gpio.c
  group Main
    ../Src/: uart_polling.c
  group Readme
    ../: Example Manual.txt
