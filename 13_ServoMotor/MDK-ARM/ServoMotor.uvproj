# Keil uVision project ServoMotor.uvproj, settings and files
target ServoMotor (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: PWM +hex
  c flags: wLevel=2
  c include: ..\..\Huins_NXP_LPC1768_Library\Core\Device\NXP\LPC17xx\Include;..\..\Huins_NXP_LPC1768_Library\Drivers\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Driver
    ../../Huins_NXP_LPC1768_Library/Drivers/source/: LPC1768_motor.c LPC1768_utility.c lpc17xx_pinsel.c lpc17xx_gpio.c lpc17xx_pwm.c lpc17xx_clkpwr.c lpc17xx_libcfg_default.c
  group Source Code
    ../Src/: servo_motor.c
  group Readme
    ../: Example Manual.txt
target Servo Motor (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: PWM +hex
  c flags: Optim=1 wLevel=2
  c include: ..\..\Huins_NXP_LPC1768_Library\Core\Device\NXP\LPC17xx\Include;..\..\Huins_NXP_LPC1768_Library\Drivers\include;..\Inc
  asm include: ..\common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
